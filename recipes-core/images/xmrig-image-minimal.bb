DESCRIPTION = "Core image with xmrig"

require xmrig-image.inc
